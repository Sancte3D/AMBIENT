# Keil uVision project Project.uvprojx, settings and files
target STM32H7_CM7_OpenAMP_PingPong (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H7_CM7_OpenAMP_PingPong
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H747xx,USE_PWR_DIRECT_SMPS_SUPPLY,CORE_CM7,USE_IOEXPANDER,VIRTIO_MASTER_ONLY,NO_ATOMIC_64_SUPPORT,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,RPMSG_BUFFER_SIZE=100
  c include: ../CM7/Inc/;../Common/Inc/;../Common/Inc/openamp/;../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include/metal/compiler/mdk-arm
  asm include: ../CM7/Inc/
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: STM32H7_CM7\Exe\STM32H7_CM7_OpenAMP_PingPong.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Application/User/CM4
    ../CM4/Src/: main_cm4.c stm32h7xx_it.c
  group Application/User/CM7
    ../CM7/Src/: main_cm7.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/Common
    ../Common/Src/: mbox_hsem.c openamp.c rsc_table.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_exti.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
  group Middlewares/OpenAMP/libmetal
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c irq.c time.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
  group Middlewares/OpenAMP/libmetal/generic
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: generic_device.c generic_init.c generic_io.c
  group Middlewares/OpenAMP/open-amp
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
target STM32H7_CM4_OpenAMP_PingPong (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x10000000-0x10047FFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4")
  output: STM32H7_CM4_OpenAMP_PingPong
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H747xx,USE_PWR_DIRECT_SMPS_SUPPLY,CORE_CM4,VIRTIO_SLAVE_ONLY,NO_ATOMIC_64_SUPPORT,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,RPMSG_BUFFER_SIZE=100
  c include: ../CM4/Inc/;../Common/Inc/;../Common/Inc/openamp/;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include/metal/compiler/mdk-arm
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: STM32H7_CM4\Exe\STM32H7_CM4_OpenAMP_PingPong.sct
software components: CMSIS:CORE 6.1.0
