# IAR project Project.ewp, settings and files
configuration STM32H7_CM7_OpenAMP_PingPong (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; STM32H747xx; CORE_CM7; VIRTIO_MASTER_ONLY; NO_ATOMIC_64_SUPPORT; METAL_MAX_DEVICE_REGIONS=2; METAL_INTERNAL; RPMSG_BUFFER_SIZE=100
  ICCARM.CCIncludePath2: ../CM7/Inc/; ../Common/Inc/; ../Common/Inc/openamp/; ../../../../../../Drivers/BSP/STM32H747I-EVAL; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../CM7/Inc/
  OBJCOPY.OOCOutputFile: STM32H7_CM7_OpenAMP_PingPong.hex
  ILINK.IlinkOutputFile: STM32H7_CM7_OpenAMP_PingPong.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H7_CM4_OpenAMP_PingPong (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; STM32H747xx; CORE_CM4; VIRTIO_SLAVE_ONLY; NO_ATOMIC_64_SUPPORT; METAL_MAX_DEVICE_REGIONS=2; METAL_INTERNAL; RPMSG_BUFFER_SIZE=100
  ICCARM.CCIncludePath2: ../CM4/Inc/; ../Common/Inc/; ../Common/Inc/openamp/; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  OBJCOPY.OOCOutputFile: STM32H7_CM4_OpenAMP_PingPong.hex
  ILINK.IlinkOutputFile: STM32H7_CM4_OpenAMP_PingPong.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/EWARM
    $EW_DIR$/arm/src/lib/atomic/: libatomic.c
    ./: startup_stm32h747xx.s
  group Application/User/CM4
    ../CM4/Src/: main_cm4.c stm32h7xx_it.c
  group Application/User/CM7
    ../CM7/Src/: main_cm7.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/Common
    ../Common/Src/: mbox_hsem.c openamp.c rsc_table.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/OpenAMP/libmetal
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c irq.c time.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
  group Middlewares/OpenAMP/libmetal/generic
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: generic_device.c generic_init.c generic_io.c
  group Middlewares/OpenAMP/open-amp
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
