# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750B-DK ST STM32H750B-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x90000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DISCO
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_QSPI_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x90000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DISCO; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSDRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0xD0000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DISCO; USE_EXTERNAL_SDRAM; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  OBJCOPY.OOCOutputFile: BootROM_ExternalSDRAM_InternalSRAM.bin
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
  group Doc
    ../: readme.txt
  group Drivers\CMSIS
    ./: startup_stm32h750xx.s
    ../Src/: system_stm32h7xx.c
  group Drivers\STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_ll_fmc.c
  group Middlewares\FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares\FreeRTOS\CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares\FreeRTOS\portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32H750B-Discovery
    ../../../../../../Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c
  group User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
