# Keil uVision project Project.uvprojx, settings and files
target XIP_NOR_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x60000000-0x60FFFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x60000000U,STM32H7B0xxQ,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_STM32H7B3I_EVAL
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Drivers/BSP/Components;../../../../../../../Drivers/BSP/Components/Common
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32h7b0xxq.s
  group Application/User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/Components
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H7B3I_EVAL
    ../../../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS_V2
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
target XIP_NOR_ExternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x60000000-0x60FFFFFF) IRAM(0x68000000-0x681FFFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x1000000
  memory RVCT9: RAM 0x68000000 size 0x200000
  memory RVCT10: RAM 0x0 size 0x10000
target XIP_NOR_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x60000000-0x60FFFFFF) IRAM(0xD0000000-0xD1FFFFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x1000000
  memory RVCT9: RAM 0xd0000000 size 0x2000000
  memory RVCT10: RAM 0x0 size 0x10000
target BootROM_ExternalSRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x68000000-0x681FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x68000000U,STM32H7B0xxQ,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_STM32H7B3I_EVAL
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target BootROM_ExternalSDRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0xD0000000-0xD1FFFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0xD0000000U,STM32H7B0xxQ,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_STM32H7B3I_EVAL
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0xd0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target XIP_OSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x90000000-0x97FFFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,STM32H7B0xxQ,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_STM32H7B3I_EVAL
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Drivers/BSP/Components/Common
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target XIP_OSPI_ExternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x90000000-0x97FFFFFF) IRAM(0x68000000-0x681FFFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x8000000
  memory RVCT9: RAM 0x68000000 size 0x200000
  memory RVCT10: RAM 0x0 size 0x10000
target XIP_OSPI_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0IBKxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x90000000-0x97FFFFFF) IRAM(0xD0000000-0xD1FFFFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,STM32H7B0xxQ,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_STM32H7B3I_EVAL,USE_IOEXPANDER
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x8000000
  memory RVCT9: RAM 0xd0000000 size 0x2000000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 4.3.0
