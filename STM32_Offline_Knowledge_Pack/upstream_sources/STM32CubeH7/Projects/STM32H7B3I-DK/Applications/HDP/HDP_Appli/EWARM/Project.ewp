# IAR project Project.ewp, settings and files
configuration HDP_appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3LI-Q ST STM32H7B3LI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H7B3xxQ
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H7B3I-DK; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Utilities\lcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H7B3I-DK.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32h7b3xxq_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h7b3xxq.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/FT5336
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/GT911
    ../../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group Drivers/BSP/Components/IS42S16800J
    ../../../../../../Drivers/BSP/Components/is42s16800j/: is42s16800j.c
  group Drivers/BSP/STM32H7B3I-DK
    ../../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c stm32h7b3i_discovery_bus.c stm32h7b3i_discovery_lcd.c stm32h7b3i_discovery_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
