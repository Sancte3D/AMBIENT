# Keil uVision project Project.uvprojx, settings and files
target BootROM_ExternalSDRAM_InternalSRAM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0xD0000000U,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B0xxQ
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Utilities/Fonts;../../../../../../../Utilities/CPU
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0xd0000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma.c
  group MDK-ARM
    ./: startup_stm32h7b0xxq.s
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS_V2
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group STM32H7B3I-Discovery
    ../../../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c
  group User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
target XIP_OSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B0xxQ
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Utilities/Fonts;../../../../../../../Utilities/CPU
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target XIP_OSPI_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0xd0000000 size 0x800000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.2.0
