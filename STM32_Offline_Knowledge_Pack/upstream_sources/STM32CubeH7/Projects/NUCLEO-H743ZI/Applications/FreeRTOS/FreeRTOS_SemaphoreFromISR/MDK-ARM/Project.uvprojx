# Keil uVision project Project.uvprojx, settings and files
target STM32H743ZI_Nucleo (6190000::V6.19::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743ZI_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY, STM32H743xx,USE_STM32H7XX_NUCLEO_144_MB1364
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c tasks.c event_groups.c croutine.c list.c stream_buffer.c
  group Application/User
    ../Src/: stm32h7xx_hal_timebase_tim.c main.c stm32h7xx_it.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Doc
    ../: readme.txt
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart.c stm32h7xx_hal_i2c.c
software components: CMSIS:CORE 6.1.0
