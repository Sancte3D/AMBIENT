# Keil uVision project Project.uvprojx, settings and files
target STM32H743ZI-Nucleo (6190000::V6.19::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743ZI-Nucleo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,STM32H743xx,USE_STM32H7XX_NUCLEO_144_MB1364
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;..\..\..\..\..\..\Drivers\BSP\Components\lan8742;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743ZI-Nucleo\STM32H743ZI-Nucleo.sct
  group Application/User
    ../Src/: stm32h7xx_hal_timebase_tim.c httpserver_netconn.c stm32h7xx_it.c app_ethernet.c main.c ethernetif.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_flash.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_i2c.c stm32h7xx_hal_mdma.c stm32h7xx_hal_eth.c stm32h7xx_hal_dma.c stm32h7xx_hal_flash_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_uart.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/LwIP/apps/http
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c ip4_frag.c etharp.c icmp.c ip4_addr.c igmp.c dhcp.c autoip.c acd.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c netdb.c tcpip.c netifapi.c netbuf.c api_lib.c api_msg.c sockets.c
  group Drivers/BSP/STM32H743ZI-Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c tasks.c list.c croutine.c stream_buffer.c event_groups.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_out.c inet_chksum.c tcp.c init.c udp.c dns.c netif.c mem.c raw.c def.c stats.c pbuf.c sys.c timeouts.c tcp_in.c memp.c ip.c
software components: CMSIS:CORE 6.1.0
