# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY, STM32H743xx, USE_STM32H743I_EVAL,USE_IOEXPANDER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/Third_Party/FatFs/src;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c event_groups.c croutine.c list.c timers.c stream_buffer.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_io.c stm32h743i_eval.c stm32h743i_eval_sd.c stm32h743i_eval_bus.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_i2c.c stm32h7xx_hal_uart.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_adc.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_sd.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dma.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_exti.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Application/User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c sd_diskio_dma_rtos.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
