# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750XB ST STM32H750XB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x90000000U; STM32H750xx; USE_HAL_DRIVER; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_CMSIS_V2
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32H743I-EVAL; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.hex
  ILINK.IlinkOutputFile: STM32H743I_EVAL.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_QSPI_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x90000000U; STM32H743xx; USE_HAL_DRIVER; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_CMSIS_V2
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32H743I-EVAL; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  OBJCOPY.OOCOutputFile: XiP_QSPI_ExternalSRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSRAM.icf
configuration XiP_QSPI_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XiP_QSPI_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSDRAM.icf
configuration XIP_NOR_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x60000000U; STM32H750xx; USE_HAL_DRIVER; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_CMSIS_V2
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_InternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_InternalSRAM.icf
configuration XIP_NOR_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_ExternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_ExtrenalSRAM.icf
configuration XIP_NOR_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_ExternaSDRAM.hex
  ILINK.IlinkIcfFile: NORflash_ExtrenalSDRAM.icf
configuration BootROM_ExternalSRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0x68000000U; STM32H750xx; USE_HAL_DRIVER; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_CMSIS_V2
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSRAM_InternalSRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; APPLICATION_ADDRESS=0xD0000000U; STM32H750xx; USE_HAL_DRIVER; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_CMSIS_V2
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
  group Components
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Doc
    ../: readme.txt
  group Drivers\CMSIS
    ./: startup_stm32h750xx.s
    ../Src/: system_stm32h7xx.c
  group Drivers\STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares\FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares\FreeRTOS\CMSIS_RTOS_V2
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares\FreeRTOS\portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32H743I-EVAL
    ../../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c
  group User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
