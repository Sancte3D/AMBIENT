# IAR project Project.ewp, settings and files
configuration STM32H743I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H743xx; USE_STM32H743I_EVAL
  ICCARM.CCIncludePath2: ../Inc; ../Src; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32H743I-EVAL; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Utilities/Lcd_Trace; ../../../../../../Utilities/LCD; ../../../../../../Drivers/BSP/Components; ../../../../../../Middlewares/Third_Party/LwIP/src/include/; ../../../../../../Middlewares/Third_Party/LwIP/system; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Utilities; ../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../Drivers/BSP/Components/lan8742
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32H743I_EVAL.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: app_ethernet.c ethernetif.c httpserver_netconn.c main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/Utilities
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
    ../../../../../../Utilities/lcd/: stm32_lcd.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/apps/http
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
