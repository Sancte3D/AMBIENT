# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,USE_STM32H743I_EVAL,USE_CMSIS_V2,STM32H743xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_LCD,USE_IOEXPANDER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Utilities/Lcd_trace;../../../../../../Utilities/LCD;../../../../../../Drivers/BSP/Components/Common;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743I_EVAL\STM32H743I_EVAL.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c croutine.c timers.c list.c queue.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
  group Middlewares/FreeRTOS/CMSIS_RTOS_V2
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c netifapi.c err.c netdb.c api_lib.c sockets.c tcpip.c api_msg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_bus.c stm32h743i_eval.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecp_curves.c havege.c base64.c ecdh.c entropy.c pkcs12.c ripemd160.c cipher.c sha512.c timing.c camellia.c aesni.c x509_create.c md.c x509write_crt.c sha1.c arc4.c pkcs11.c error.c x509_csr.c md_wrap.c rsa.c cmac.c oid.c version_features.c pkwrite.c ssl_ticket.c ecp.c ssl_cookie.c ssl_srv.c ssl_ciphersuites.c blowfish.c pkcs5.c ssl_cli.c asn1write.c gcm.c ssl_tls.c md2.c padlock.c threading.c x509_crt.c aes.c hmac_drbg.c pem.c ecjpake.c md4.c ctr_drbg.c certs.c chacha20.c chachapoly.c pkparse.c des.c md5.c x509_crl.c xtea.c ssl_cache.c dhm.c sha256.c pk.c cipher_wrap.c ccm.c x509write_csr.c debug.c asn1parse.c x509.c version.c entropy_poll.c pk_wrap.c platform.c bignum.c ecdsa.c memory_buffer_alloc.c nist_kw.c aria.c hkdf.c platform_util.c poly1305.c rsa_internal.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: init.c inet_chksum.c dns.c netif.c sys.c stats.c tcp_in.c udp.c tcp_out.c mem.c tcp.c pbuf.c def.c raw.c ip.c timeouts.c memp.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma.c stm32h7xx_hal_rng.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_tim.c stm32h7xx_hal_uart.c stm32h7xx_hal_cortex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_exti.c
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/Legacy/: stm32h7xx_hal_eth.c
  group Application/User
    ../Src/: main.c stm32h7xx_it.c net_sockets.c ethernetif.c stm32h7xx_hal_timebase_tim.c hardware_rng.c ssl_client.c stm32h7xx_hal_msp.c
    ./: retarget.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c igmp.c etharp.c ip4_frag.c autoip.c ip4.c icmp.c ip4_addr.c
  group Utilities/Log
    ../../../../../../Utilities/lcd/: stm32_lcd.c
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
software components: CMSIS:CORE 4.3.0
