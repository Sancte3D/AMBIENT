# Keil uVision project Project.uvprojx, settings and files
target STM32H743I-EVAL_USBH-FS (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,USE_USB_FS
  c misc: -U__GNUC__
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/Include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/Lcd_Trace;../../../../../../Utilities/LCD;../../../../../../Drivers/BSP/Components/Common;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_i2c.c stm32h7xx_hal_gpio.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_sai.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_rcc.c stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_uart.c stm32h7xx_hal_sram.c stm32h7xx_hal_flash.c stm32h7xx_hal_tim.c stm32h7xx_hal_pwr.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c_ex.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_parser.c usbh_hid_mouse.c usbh_hid_keybd.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
  group Application/User
    ../Src/: main.c keyboard.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c usbh_conf.c mouse.c menu.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c event_groups.c list.c queue.c croutine.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
target STM32H743I-EVAL_USBH-HS (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743I-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,USE_USB_HS
  c misc: -U__GNUC__
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/Include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/LCD;../../../../../../Utilities/Lcd_Trace;../../../../../../Drivers/BSP/Components/Common
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 6.1.1
